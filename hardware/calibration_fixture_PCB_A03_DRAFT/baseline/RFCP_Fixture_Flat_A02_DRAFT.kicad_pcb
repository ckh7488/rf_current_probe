# Repository ckh7488/rf_current_probe

File README.md:

# RF 전류 프로브 소스 보관

2026-11-04 시점에 보존한 설계·분석 소스와 선택된 결과입니다.

- [원 프로젝트의 현재 구성 문서](docs/CURRENT_BUILD.md), [설계 명세](docs/current_build.json)
- hardware/: 프로브 헤드·교정지그의 KiCad 및 CAD 원본. VNA 보드 4종은 reviews/jlc_renewal_preflight_20260929/candidate/에 있습니다.
- analysis/: RF 분석 및 시뮬레이션 코드와 requirements.txt.
- mechanical/: A17·A18·A19 CAD, 부품 STEP/STL, 생성 스크립트. A19 builder가 읽는 기준 CAD는 reviews/base_dfm_fix_20260928/에 포함했습니다.
- viewer_A05/: 안내·조립 화면의 소스와 정적 의존성. dist는 재생성 대상입니다.
- selected-evidence/: 경력 문서에 연결한 저장 결과. 시뮬레이션과 실측을 구분해 읽습니다.

전체 FEM 출력·반복 mesh.json·설치 런타임·제조 ZIP·구매 전달 파일은 제외했습니다. 원 프로젝트 문서의 이들 경로는 이 소스 보관본에 없을 수 있습니다. A17/A18 이전 버전부터 모든 CAD를 연속 재생성하는 묶음이 아니며, 포함된 CAD를 기준으로 검토합니다. 전체 과거 자료는 SYNC_CHECKPOINT_20261104.json의 원본 경로에 남아 있습니다.

최신 실측 sweep의 경력 문서 연결은 아직 남아 있습니다. 이 저장소 업로드를 새 계측·제조 승인으로 해석하지 않습니다. 원본 위치·해시는 SYNC_CHECKPOINT_20261104.json 및 SYNC_SUPPLEMENT_20261104.json에 기록했습니다.

## KiCad design hardware/calibration_fixture_PCB_A03_DRAFT/baseline/RFCP_Fixture_Flat_A02_DRAFT.kicad_pcb

File hardware/calibration_fixture_PCB_A03_DRAFT/README.md:

# 교정 PCB A03 — 외형 유지, SMA 홀 여유 보완

> **2026-09-23 현행 교정지그 ([DEC-053](../../docs/DECISIONS.md)).** 이 A03를 유일한 현행 교정지그로 사용하며1–500 MHz 보정을 수행한다. −6 dB 전달 감소 자체를 상단 대역 제외 사유로 사용하지 않는다. 주파수별 ZT·불확도·유효성을 기록한다. 판정 기준은 빈 지그 S11이 아니라 출력 포트 기준 코어 전류다(백서 11.6). 아래 해석의 100 MHz S11 −20 dB 미달은 기록으로 유지하되 교정 판정 조건이 아니다. 저장 모델의 코어/출구 보정량 K는 100/300/500 MHz 약0.05–0.10/0.41–0.78/0.87–1.65 dB다. [채택 근거](../../reviews/fixture_a03_output_reference_20260923/ENGINEERING.md). PCB·제조 ZIP은 변경하지 않았다. 조립 부품: SMA 2개(E04), PA66 M3×12 나사·날개너트 각4(F13/F14).

> 2026-09-22 추가 제출 전 검토: 실제 ZIP의 동박/드릴/마스크와 최대 PCB 조립 간섭, 네 고정홀의 복합 치수 공차를 확인했습니다. 이 PCB와 제조 ZIP은 변경하지 않았으며 [제출 대상·제조 옵션](../../reviews/submission_freeze_20260922/MANUFACTURING_HANDOFF.md)을 고정했습니다.

> 2026-09-22 재검토: 보존 원본에서 재생성한 PCB/회로도와 현행 파일의 바이트 일치, 라이브러리/드릴/ZIP 일치, ERC/DRC/회로 일치 오류0을 다시 확인했습니다. PCB·제조 ZIP·출력 형상은 추가 변경하지 않았습니다. [새 검토 기록](../../reviews/recheck_20260922/README.md).

2026-09-21 · **DRAFT — NOT FOR FABRICATION**

A02와 동일한 144×92.7×1.6 mm 외곽·창·고정홀·중앙 신호·외부 귀환 구조를 사용한다. 두 SMA의 중심홀을 Ø1.50→1.70 mm, 접지홀을 Ø1.70→1.90 mm로 넓혔다. 패드 외경·SMA 위치·신호 배선·비아는 같다. BaseCenter 및 출력물 장착 인터페이스는 같다.

헤드와 같은 GCT RFPC-SMA28-F를 사용하므로 [같은 공차 보완](../../reviews/design_closure_20260921/sma/fit_result.json)을 적용한다. 기존 A02는 보존한다.

- [KiCad PCB](RFCP_Fixture_Flat_A03_DRAFT.kicad_pcb), [회로](RFCP_Fixture_Flat_A03_DRAFT.kicad_sch), [프로젝트](RFCP_Fixture_Flat_A03_DRAFT.kicad_pro)
- [제조 검토용 ZIP](RFCP_Fixture_Flat_A03_DRAFT_REVIEW_ONLY.zip), [저장 파일·드릴 대조](review/revision_verification.json)
- [ERC](review/erc.json), [DRC](review/drc.json), [재생성 코드](build_revision.py)

`build_revision.py`는 보존한 A02 원본에서 홀과 리비전 표기만 바꾸며 KiCad 10 Python으로 실행한다. 프로젝트 루트의 `analysis/export_sma_revisions.py`, `analysis/verify_sma_revisions.py`가 내보내기와 독립 대조를 수행한다.

현행 전자기 해석은 기존 중실비아7조건과 추가 Z격자2조건의 [새 환산과 판정](../../reviews/document_full_audit_20260922/RF_REFINEMENT.md)을 따른다. Z0.3→0.2 mm의1–100/100–300 MHz 최대 복소 전류 차이는 0.2168% / 1.7206%, Z0.2→0.15 mm는 0.2564% / 2.1231%다. 차이는 단조 감소하지 않으므로 수렴 차수나 연속해 오차 상한을 확정하지 않는다. 새 모델의100 MHz S11도 각각−16.23/−16.73 dB로−20 dB 목표 미달이다. 기존0.5/0.3 mm의100–300 MHz 차4.5949% 미달은 보존한다. 마지막 두 격자 비교가 전체3D 수렴이나 실물 정밀도를 보증하지 않는다. 빈 지그 모델을 코어·권선·실제 케이블이 포함된 교정으로 사용하지 않으며,50S21을 자동 적용하지 않는다.

첫 실물에서는 5핀 삽입·평면 안착·납땜 충전, 무코어/헤드 장착 상태 S2P 및 전류 모델을 검증한다.

## 실제 제출 상태

2026-09-22 JLC `Y22-9961994A`로5장 접수했다. [17:25 접수 기록](../../procurement/jlc_refresh_20260922/README.md)에서는 Reviewing이었으며 [18:49 KST 재조회](../../reviews/document_full_audit_20260922/jlc_observation_1849.json)에서 Approved, RF 묶음은 Awaiting Payment로 바뀌었다. 수동 생산 파일 확인 조건은 유지되며 결제·생산 파일 승인은 실행하지 않았다. 추가 Z격자 계산과 문서 대조는 [전수 조사 보고서](../../reviews/document_full_audit_20260922/README.md)를 따른다. 과거 해석 결과를 덮어쓰지 않는다.

Parts:
J1, J2: RFPC-SMA28-F; GCT_RFPC_SMA28_F

Connections:
/GND: J1.2, J2.2
/SIG: J1.1, J2.1

Notes on the sheet:
DRAFT - NOT FOR FABRICATION
SINGLE PLANAR PCB: 144 x 92.7 x 1.6 mm; corner mounts 130 x 76.7 mm.
J1/J2: GCT RFPC-SMA28-F vertical through-hole SMA; no wire jumpers.
SIG only on BOTH faces of center bridge. All GND returns outside the core.
No ground plane below center bridge; two routed windows are mandatory.
Four M3 nylon columns: 30 mm female/female + 35 mm male/female each.
Connector launches and fixture current model are NOT impedance-qualified.
NO on-board 50 ohm termination; use defined external receiver/load.

Board: 2 copper layers, 6 parts (0 on the bottom side), 2 nets, no tracks yet.

Other parts of the board:
H1, H2, H3, H4: NYLON_M3

## KiCad design reviews/jlc_renewal_preflight_20260929/candidate/te/m12_slipring.kicad_pcb

Parts:
J1: RJ45 RJE591885401; RJ45_Amphenol_RJE59-188-5401
J2: T4143012081-000; TE_T4143012081-000
TP1: Shield_SolderPoint

Connections:
/PAIR_A_N: J1.2, J2.3
/PAIR_A_P: J1.1, J2.4
/PAIR_B_N: J1.6, J2.1
/PAIR_B_P: J1.3, J2.2
/SHIELD: J1.SH, TP1.1

Notes on the sheet:
M12 FEMALE / SLIPRING; 5-8 NC; VERIFY MATE
Passive two-pair adapter; no magnetics, no PoE, no active Ethernet.
100 ohm pair trunks; JLC04161H-7628; 4 layers; 1.6 mm nominal.
Inner SHIELD planes connect to RJ45 shield. M12 body bond is mechanical/external.
TE drawing matched; external bracket fixes rear PCB spacing about 3 mm.
Calibration reference plane: DUT connector mating plane after this adapter.

Board: 4 copper layers, 66.0 x 40.0 mm, 7 parts (0 on the bottom side), 5 nets.

Other parts of the board:
H1, H2, H3, H4: (no value)

## KiCad design reviews/jlc_renewal_preflight_20260929/candidate/molex/molex_slipring.kicad_pcb

Parts:
J1: RJ45 RJE591885401; RJ45_Amphenol_RJE59-188-5401
J2: 5055680571; Molex_5055680571

Connections:
/PAIR_A_N: J1.2, J2.2
/PAIR_A_P: J1.1, J2.1
/PAIR_B_N: J1.6, J2.4
/PAIR_B_P: J1.3, J2.3
/SHIELD: J1.SH

Notes on the sheet:
MOLEX 5P / SLIPRING; PIN 5 NC; VERIFY HOUSING
Passive two-pair adapter; no magnetics, no PoE, no active Ethernet.
100 ohm pair trunks; JLC04161H-7628; 4 layers; 1.6 mm nominal.
Inner SHIELD planes connect to RJ45 shield; no DUT-side shield bond.
Molex housing and actual mating/pin numbering require sample verification.
Calibration reference plane: DUT connector mating plane after this adapter.

Board: 4 copper layers, 66.0 x 40.0 mm, 6 parts (0 on the bottom side), 4 nets.

Other parts of the board:
H1, H2, H3, H4: (no value)

## KiCad design reviews/jlc_renewal_preflight_20260929/candidate/common/balun_eth_rj45.kicad_pcb

Parts:
CSH1: 1nF 2kV DNP; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder; not fitted
J1: RJE591885401 CAT6 NO-MAGNETICS; RJ45_Amphenol_RJE59-188-5401; MPN RJE591885401; LCSC Part # C5386678
J2: SMA_A; SMA_Samtec_SMA-J-P-H-RA-TH1; MPN SMA-J-P-H-RA-TH1
J3: SMA_B; SMA_Samtec_SMA-J-P-H-RA-TH1; MPN SMA-J-P-H-RA-TH1
J4: SMA_C; SMA_Samtec_SMA-J-P-H-RA-TH1; MPN SMA-J-P-H-RA-TH1
J5: SMA_D; SMA_Samtec_SMA-J-P-H-RA-TH1; MPN SMA-J-P-H-RA-TH1
RCT1, RCT2, RCT3, RCT4: 0R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; MPN 0805W8F0000T5E; LCSC Part # C17477; not fitted
RSH1: 0R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; MPN 0805W8F0000T5E; LCSC Part # C17477; not fitted
T1, T2, T3, T4: ADT2-1T+; Mini-Circuits_CD542_H2.84mm; MPN ADT2-1T+; LCSC Part # C5223988
TP1: GND_RF; TestPoint_Loop_D2.50mm_Drill1.0mm; not fitted
TP2: RJ45_SHIELD; TestPoint_Loop_D2.50mm_Drill1.0mm; not fitted

Connections:
/DA_N: J1.2, T1.6
/DA_P: J1.1, T1.4
/DB_N: J1.6, T2.6
/DB_P: J1.3, T2.4
/DC_N: J1.5, T3.6
/DC_P: J1.4, T3.4
/DD_N: J1.8, T4.6
/DD_P: J1.7, T4.4
/GND: CSH1.1, J2.2 (Ext), J3.2 (Ext), J4.2 (Ext), J5.2 (Ext), RCT1.1, RCT2.1, RCT3.1, RCT4.1, RSH1.1, T1.1, T2.1, T3.1, T4.1, TP1.1
/SHIELD: CSH1.2, J1.SH, RSH1.2, TP2.1
unnamed: J2.1 (In), T1.3
unnamed: J3.1 (In), T2.3
unnamed: J4.1 (In), T3.3
unnamed: J5.1 (In), T4.3
unnamed: RCT1.2, T1.5
unnamed: RCT2.2, T2.5
unnamed: RCT3.2, T3.5
unnamed: RCT4.2, T4.5

Notes on the sheet:
RJ45 / FOUR-PAIR VNA FIXTURE
RJ45 이더넷 케이블 측정 지그 | 4-channel VNA fixture
A / RJ45 1(+) - 2(-)
50 ohm
DNP / CT FLOAT
1:2 impedance
B / RJ45 3(+) - 6(-)
C / RJ45 4(+) - 5(-)
D / RJ45 7(+) - 8(-)
RJ45 / NO MAGNETICS
Component pin numbers, not a mating-face drawing.
SHIELD OPTIONS / TEST POINTS
DNP IN COMMON CAD
OPTIONAL AC BOND / DNP
PCBA: SHIELD-BONDED / SHIELD-FLOAT variants.
Supplier fits RSH1 only on the BONDED boards.
ASSEMBLY / MEASUREMENT NOTES
1. Passive DUT only. Disconnect PoE and all active Ethernet equipment before connecting the VNA.
2. Two identical PCB artworks; measure one path at a time and terminate all six unused SMA ports with 50 ohm loads.
3. RCT1..RCT4 are DNP on this board. The default comparison condition is CT-FLOAT on both endpoint boards.
4. CT-GND is a separate controlled comparison: fit all eight RCTs across two boards; do not mix CT states.
5. This common CAD keeps RSH1 and CSH1 DNP. Final PCBA variants follow PCBA_PURCHASE_SCOPE_2026-09-03.md.
6. RSH1 fitted = direct shield bond; CSH1 alone = optional AC bond; both DNP = floating. Never fit both together.
7. Final shield variants are assembled by the supplier; legacy hand-fit property text is not a user soldering instruction.
8. Coax O/S/L + THRU calibration leaves the PCB / balun response embedded. Keep REF/DUT fixture conditions fixed.
9. Secondary convention P=pin 4, N=pin 6 is unchanged. Account for single-fixture polarity in phase/de-embedding work.
10. No TVS, common-mode choke, MagJack, series capacitors or on-board 50 ohm loads are added to the signal paths.

Board: 4 copper layers, 80.0 x 74.0 mm, 21 parts (8 on the bottom side), 18 nets.

Other parts of the board:
H1, H2, H3, H4: M3; MountingHole_3.2mm_M3
